options:
  parameters:
    generate_options: no_gui
    id: openlst_downlink
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: bit_rate
  id: variable
  parameters:
    value: '7415.77'
  states: {}
- name: resamp_rate
  id: variable
  parameters:
    value: '4'
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: samp_rate/bit_rate
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 250e3
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: resamp_rate
    sensitivity: '1.0'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: resamp_rate
    resamp_type: digital.IR_MMSE_8TAP
    sps: resamp_rate
    ted_gain: '1'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: downlink_freq
  id: parameter
  parameters:
    type: intx
    value: '400200000'
  states: {}
- name: downlink_gain
  id: parameter
  parameters:
    type: intx
    value: '40'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 50e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: mmse_resampler_xx_0_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: samp_per_sym/resamp_rate
    type: complex
  states: {}
- name: openlst_openlst_demod_0
  id: openlst_openlst_demod
  parameters:
    client_format: '''CLIENT_PACKET'''
    fec: 'True'
    preamble_quality: '30'
    whitening: 'True'
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: downlink_freq
    gain: downlink_gain
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [digital_gfsk_demod_0, '0', openlst_openlst_demod_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_gfsk_demod_0, '0']
- [low_pass_filter_0, '0', mmse_resampler_xx_0_0, '0']
- [mmse_resampler_xx_0_0, '0', digital_symbol_sync_xx_0, '0']
- [openlst_openlst_demod_0, message, blocks_message_debug_0, print]
- [soapy_rtlsdr_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
